options:
  parameters:
    author: neilp
    generate_options: qt_gui
    id: Tx_Rx__USRP
    output_language: python
    title: Tx_Rx__USRP
  states: {}

blocks:
- name: audio_decim
  id: variable
  parameters:
    value: (int)(demod_rate/48000)
  states: {}
- name: audio_rate
  id: variable
  parameters:
    value: 44.1e3
  states: {}
- name: center_frecuency
  id: variable
  parameters:
    value: '104000000'
  states: {}
- name: center_freq
  id: variable_qtgui_range
  parameters:
    label: Frequency
    start: '88000000'
    step: '200000'
    stop: '108000000'
    value: '102100000'
  states: {}
- name: demod_rate
  id: variable
  parameters:
    value: (int)(samp_rate/rf_decim)
  states: {}
- name: rf_decim
  id: variable
  parameters:
    value: '2'
  states: {}
- name: rf_gain
  id: variable_qtgui_range
  parameters:
    label: RF Gain
    start: '0'
    step: '1'
    stop: '70'
    value: '50'
    widget: slider
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '768000'
  states: {}
- name: samp_rate_0
  id: variable
  parameters:
    value: '768000'
  states: {}
- name: samp_rate_1
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: samp_salida
  id: variable
  parameters:
    value: '300000'
  states: {}
- name: sq_lvl
  id: variable_qtgui_range
  parameters:
    label: Squelch
    start: '-100'
    step: '5'
    stop: '0'
    value: '-50'
  states: {}
- name: usrp_rate
  id: variable
  parameters:
    value: '576000'
  states: {}
- name: volume
  id: variable_qtgui_range
  parameters:
    label: Volume
    start: '0'
    step: '0.05'
    stop: '1.0'
    value: '0.2'
    widget: slider
  states: {}
- name: volume_in
  id: variable_qtgui_range
  parameters:
    label: Volume_in
    start: '0'
    step: '0.250'
    stop: '5'
    value: '1'
    widget: slider
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '0.150'
    freq: '0'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate_1
    type: float
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: analog_simple_squelch_cc_0
  id: analog_simple_squelch_cc
  parameters:
    alpha: '1'
    threshold: sq_lvl
  states: {}
- name: analog_wfm_rcv_pll_0
  id: analog_wfm_rcv_pll
  parameters:
    audio_decimation: audio_decim
    deemph_tau: '75e-6'
    quad_rate: (int)(samp_rate/rf_decim)
  states: {}
- name: analog_wfm_tx_0
  id: analog_wfm_tx
  parameters:
    audio_rate: samp_rate_1
    fh: '-1.0'
    max_dev: 75e3
    quad_rate: '192000'
    tau: '75e-6'
  states: {}
- name: audio_sink_0_0
  id: audio_sink
  parameters:
    num_inputs: '2'
    samp_rate: '48000'
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: '20000'
    low_cutoff_freq: '100'
    samp_rate: samp_rate_1
    type: fir_filter_fff
    width: '200'
    win: window.WIN_HAMMING
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: volume_in
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: volume
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0_0
  id: blocks_multiply_const_vxx
  parameters:
    comment: Volume
    const: volume
    type: float
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: C:\Users\neilp\Downloads\Himno-de-Arequipa.wav
    repeat: 'True'
  states: {}
- name: filter_fft_low_pass_filter_0
  id: filter_fft_low_pass_filter
  parameters:
    cutoff_freq: '90000'
    decim: '1'
    gain: '1'
    samp_rate: '192000'
    type: ccc
    width: '20000'
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '5000'
    decim: '1'
    gain: '1'
    samp_rate: '192000'
    type: fir_filter_ccf
    width: '2000'
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: center_freq
    fftsize: '1024'
    name: Señal demodulada
    showrf: 'True'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    label1: Modulated
    name: Señal Modulada
    size: '2048'
    srate: usrp_rate
    type: float
    ymax: '1.01'
    ymin: '0.99'
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    bw0: '55000'
    center_freq0: center_frecuency
    gain0: '50'
    samp_rate: samp_salida
    sync: none
    type: fc32
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    center_freq0: center_frecuency
    dev_addr: ''
    dev_args: '""'
    gain0: rf_gain
    rx_agc0: Disabled
    samp_rate: samp_salida
    sync: none
    type: fc32
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_add_xx_0, '0']
- [analog_simple_squelch_cc_0, '0', uhd_usrp_sink_0, '0']
- [analog_wfm_rcv_pll_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [analog_wfm_rcv_pll_0, '1', blocks_multiply_const_vxx_0_0_0, '0']
- [analog_wfm_tx_0, '0', low_pass_filter_0, '0']
- [band_pass_filter_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_add_xx_0, '0', analog_wfm_tx_0, '0']
- [blocks_complex_to_mag_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_add_xx_0, '1']
- [blocks_multiply_const_vxx_0_0, '0', audio_sink_0_0, '0']
- [blocks_multiply_const_vxx_0_0_0, '0', audio_sink_0_0, '1']
- [blocks_wavfile_source_0, '0', band_pass_filter_0, '0']
- [filter_fft_low_pass_filter_0, '0', analog_wfm_rcv_pll_0, '0']
- [filter_fft_low_pass_filter_0, '0', qtgui_sink_x_0, '0']
- [low_pass_filter_0, '0', analog_simple_squelch_cc_0, '0']
- [low_pass_filter_0, '0', blocks_complex_to_mag_0, '0']
- [uhd_usrp_source_0, '0', filter_fft_low_pass_filter_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.10.0
